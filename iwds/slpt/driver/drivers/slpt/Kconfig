## iwds/slpt/driver/drivers/slpt/Kconfig
```kconfig
menu "Slpt Drivers"

config SLPT
	bool "slpt driver"
	select FB_DISPLAY_ALWAYS_ON
	help

endmenu
```
